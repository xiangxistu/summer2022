# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: APM32F103ZE Geehy APM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: RT_USING_DLIBC; APM32F10X_HD; __RTTHREAD__; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\libcpu\arm\cortex-m3; ..\..\..\components\finsh; ..\..\..\libcpu\arm\common; ..\..\..\components\libc\posix\ipc; ..\libraries\Drivers; ..\libraries\Drivers\config; ..\..\..\components\drivers\include; ..\..\..\examples\utest\testcases\kernel; .; ..\libraries\APM32F10x_Library\Device\Geehy\APM32F10x\Include; applications; ..\libraries\APM32F10x_Library\APM32F10x_StdPeriphDriver\inc; board; ..\..\..\components\libc\compilers\common; ..\..\..\components\libc\posix\io\poll; ..\libraries\APM32F10x_Library\CMSIS\Include; ..\..\..\include; ..\..\..\components\libc\compilers\common\nogcc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: template.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; RT_USING_DLIBC; APM32F10X_HD; __RTTHREAD__; USE_STDPERIPH_DRIVER
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: time.c stdlib.c
    ../../../components/libc/compilers/dlib/: syscalls.c syscall_write.c syscall_mem.c syscall_remove.c environ.c syscall_close.c syscall_read.c syscall_lseek.c syscall_open.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m3/: cpuport.c context_iar.S
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: waitqueue.c workqueue.c completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c
  group Drivers
    ../libraries/APM32F10x_Library/Device/Geehy/APM32F10x/Source/iar/: startup_apm32f10x_hd.s
    board/: board.c
    ../libraries/Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: scheduler.c mem.c components.c mempool.c kservice.c ipc.c clock.c object.c timer.c irq.c idle.c device.c thread.c
  group Libraries
    ../libraries/APM32F10x_Library/Device/Geehy/APM32F10x/Source/: system_apm32f10x.c
    ../libraries/APM32F10x_Library/APM32F10x_StdPeriphDriver/src/: apm32f10x_rcm.c apm32f10x_misc.c apm32f10x_usart.c apm32f10x_eint.c apm32f10x_gpio.c
